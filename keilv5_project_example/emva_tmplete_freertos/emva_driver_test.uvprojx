# Keil uVision project emva_driver_test.uvprojx, settings and files
target emva_tmplete_os (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: emva_usbhidgps +hex
  AfterMake: fromelf --bin !L --output app.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xE,CUSTOM_CONFIG,USE_USB_OTG_FS,USE_STM324xG_EVAL,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: .\arch\stm32f411xe\FWLIB\inc;.\arch\stm32f411xe\CORE;.\emva\include;.\bsp;.\os\freertos\include;.\os\freertos\portable\RVDS\ARM_CM4F;.\app;.\utils;.\USB_APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ./app/: app_main.c
  group start
    ./app/: main.c
  group emva_lib
    ./emva/lib/: emva_lib.lib
  group emva_mpool
    ./emva/mpool/: mpool.c
  group emva_bsp
    ./bsp/: bsp.c arch_stm32f411xx.c os.c
  group arch
    ./arch/stm32f411xe/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./arch/stm32f411xe/CORE/: startup_stm32f411xe.s system_stm32f4xx.c
  group freertos
    ./os/freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./os/freertos/portable/RVDS/ARM_CM4F/: port.c
    ./os/freertos/portable/MemMang/: heap_4.c
  group utils
    ./utils/: user_string.c
