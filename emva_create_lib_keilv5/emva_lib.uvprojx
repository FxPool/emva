# Keil uVision project emva_lib.uvprojx, settings and files
target emva_lib (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: emva_lib (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EMVA_CREATE_LIB,EMVA_ARCH_STM32F10X
  c include: ..\emva_source\thirdparty\cjson;..\emva_source;..\emva_source\mcu_support;..\emva_source\device\time;..\emva_source\framework\event_os;..\emva_source\device\serial;..\emva_source\device\button;..\emva_source\device\net;..\emva_source\device\power;..\emva_source\device\wifi;..\emva_source\framework\observer;..\emva_source\framework\fmt;..\emva_source\framework\kfifo;..\emva_source\framework\map;..\emva_source\framework\serial_module;..\emva_source\framework\list;..\emva_source\util;..\emva_source\framework\error;..\emva_source\framework\event_os;..\emva_source\framework\iterator;..\emva_source\framework\serialization;..\emva_source\mem;..\emva_source\drmanage\driver_init;..\emva_source\drmanage\character_dev;..\emva_source\drmanage\net_dev
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group emva
    ../emva_source/: emva.c emva_config.h
  group thirdparty
    ../emva_source/thirdparty/cjson/: cJSON.c cJSON_Utils.c
  group device
    ../emva_source/device/button/: emva_button.c
    ../emva_source/device/net/: emva_net.c
    ../emva_source/device/power/: emva_pmic.c
    ../emva_source/device/serial/: emva_serial.c
    ../emva_source/device/time/: emva_time.c
    ../emva_source/device/wifi/: emva_wifi.c
  group drmanage
    ../emva_source/drmanage/character_dev/: dv_character_device.c
    ../emva_source/drmanage/driver_init/: dev_init.c
    ../emva_source/drmanage/net_dev/: dv_net_device.c
  group framework
    ../emva_source/framework/error/: emva_error.c
    ../emva_source/framework/event_os/: emva_os.c
    ../emva_source/framework/fmt/: emva_fmt.c
    ../emva_source/framework/iterator/: emva_Iterator.c
    ../emva_source/framework/kfifo/: emva_kfifo.c
    ../emva_source/framework/led/: emva_led.c
    ../emva_source/framework/list/: emva_list.c
    ../emva_source/framework/map/: emva_map.c
    ../emva_source/framework/observer/: emva_observer.c
    ../emva_source/framework/serialization/: emva_serialization.c
    ../emva_source/framework/serial_module/: emva_serial_module.c
  group util
    ../emva_source/util/: util.c
